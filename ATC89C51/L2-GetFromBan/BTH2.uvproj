# Keil uVision project BTH2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: BTH2_VD6-ASM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Souce Group1
    ./: BTH2-vande5.c
