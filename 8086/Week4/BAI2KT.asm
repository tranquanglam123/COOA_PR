JMP MAIN
MAIN1:MOV AH,2H
MOV DL,'F'
INT 21H
MAIN:MOV CL,0AH
MOV AH,1H
INT 21H
AND AX,0FH
MUL CL
MOV BX,AX
MOV AH,1h
INT 21H
AND AX,0FH
ADD AX,BX
MUL CL
MOV BX,AX 
MOV AH,1h
INT 21H
AND AX,0FH
ADD AX,BX
CMP AX,63H
JLE MAIN1
CMP AX,3E7H
JG MAIN1
JLE CHANLE

CHANLE:
MOV CX,AX
MOV DX,0H
MOV BX,2H
DIV BX
CMP DX,0H
JE MAIN1
MOV AH,2H
MOV DL,'T'
INT 21H
JMP NHAPB

NHAPB:
MOV BX,0H
JMP MAIN2
MAIN3:MOV AH,2H
MOV DL,'F'
INT 21H
MAIN2:MOV DL,0AH
MOV AH,1H
INT 21H
AND AX,0FH
MUL DL
MOV BX,AX
MOV AH,1h
INT 21H
AND AX,0FH
ADD AX,BX
MUL DL
MOV BX,AX 
MOV AH,1h
INT 21H
AND AX,0FH
ADD AX,BX
CMP AX,CX ; CX LUU A , AX LUU B 
JG NT
JLE MAIN3

NT: 
MOV BX,AX
MOV AH,2H
MOV DL,'T'
INT 21H 
MOV AX,BX
NT1:MOV DX,0H
MOV BX,10
DIV BX 
PUSH DX
MOV DL,3H
CMP AX,0H
JE L1
JG NT1

L1:
POP BX
ADD AX,BX
DEC DL
CMP DL,0H
JE L2
JG L1

L2:
MOV DL,10
DIV DL
MOV BL,AH
MOV AH,2H
MOV DL,AL
ADD DL,30H
INT 21H
MOV AH,2H
MOV DL,BL
ADD DL,30H
INT 21H 

;KIEMTRASAONGUYENTO 

MOV BX,3H
P:MOV AX,CX
MOV DX,0H 
DIV BX
INC BX
CMP DX,0H
JE NP
CMP BX,CX
JL P
MOV DL,'P'
JMP EXIT
NP: 
MOV DL,'N'
JMP EXIT
EXIT:MOV AH,2H
INT 21H 


 
