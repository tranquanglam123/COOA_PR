MAIN:MOV CL,0AH
MOV AH,1H
INT 21H
SUB AL,30H
MUL CL
MOV BX,AX
MOV AH,1h
INT 21H
SUB AL,30H
ADD AL,BL
CMP AL,9H
JLE NHAPLAI
CMP AL,0FH
JG NHAPLAI
MOV CL,AL
JLE NHAPBIN



NHAPLAI:
MOV AH,2h
MOV DL,'F'
INT 21H
JMP MAIN


NHAPBIN:
MOV AH,1H
INT 21H
AND AX,0FH
PUSH AX
DEC CL
INC CH
CMP CL,0H
JE ECUSE
JG NHAPBIN

ECUSE:
POP BX
OR DX,BX 
ROR DX,1
INC CL
DEC CH
CMP CH,0H
JE CODINH 
JG ECUSE
CODINH:
MOV AL,10H
SUB AL,CL
MOV CL,AL
SHR DX,CL
MOV AX,DX
MOV DX,0H
JMP PRINT
PRINT:
MOV BX,10
DIV BX
INC CH
PUSH DX 
MOV DX,0H
CMP AX,0H
JE EXIT
JG PRINT
EXIT:
DEC CH
POP DX
ADD DL,30H
MOV AH,2h
INT 21h
CMP CH,0H
JE EXIT2
JG EXIT
EXIT2: 





